Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Electrical_Controls_SOMFY_Weather-Station-M10-M25.ifc
Time: 2018-12-03T03:09:39
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcDistributionControlElement: Weather Station M10&M25
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Weather Station M10&M25; SKU (BO_prodsku): M10_1860317-M25_1860319; ManufacturName (BO_Manufac): SOMFY; BrandUrl (BO_brandurl): https://www.somfysystems.com/; ManufacturCountry (BO_mancont): Germany; EditionNumber (BO_edinum): 1; Width (BO_width): 100; Height (BO_height): 100; Depth (BO_depth): 100; Weight (BO_weight): 180; QR (BO_boqrurl): http://bimobject.com/somfy/product/M10_1860317-M25_1860319; ProductDataUrl (BO_prodaturl): bimobject.com/somfy/product/M10_1860317-M25_1860319; ProductUrl (BO_producturl): https://www.somfy.com/projects/downloads; InstallationInstructions (BO_montins): https://www.somfy.com/projects/downloads; EanCode (BO_ean): 3660849542429/M10 3660849542436/M25; MaterialMain (BO_mainmat): Polycarbonate; BimObjectMainCategory (BO_bomaincat): Electrical; BimObjectMainCategoryCode (BO_bomaincat_code): electrical; BimObjectCategory (BO_bocat): Controls; BimObjectCategoryCode (BO_bocat_code): electrical-controls; IfcClassification (BO_ifcclas): Controller; UnspcCode (BO_unspc): 39121432; Uniclass14Code (BO_uniclass_1_4_code): L74; Uniclass14Description (BO_uniclass_1_4_desc): Electric power and lighting services products; Uniclass20Code (BO_uniclass_2_0_code): PR-16-16-26; Uniclass20Description (BO_uniclass_2_0_desc): Electrical Automatic Controllers And Delay Devices; Uniclass2015Code (BO_uniclass2015_code): Ac_70; Uniclass2015Description (BO_uniclass2015_desc): Electrical activities; NBSReference (BO_nbs_ref): 16-16-26; NBSReferenceDescription (BO_nbs_desc): Electrical Automatic Controllers And Delay Devices; OmniClassCode (BO_omniclass_code): 23-35 00 00; OmniClassDescription (BO_omniclass_name): Electrical and Lighting Specific Products and Equipment; MasterFormat2014Code (BO_masterformat2014_code): 26 09 16; MasterFormat2014Description (BO_masterformat2014_name): Electrical Controls and Relays; UniFormat2Code (BO_uniformat2_code): D5090; UniFormat2Description (BO_uniformat2_name): Other Electrical Systems; RegionEurope (BO_europe): AL, AT, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FR, GB, GR, HR, HU, IE, IS, IT, LT, LU, LV, MD, ME, MK, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, UA; RegionNorthAmerica (BO_northamerica): BS, BZ, CA, CR, CU, DO, GL, GT, HN, HT, JM, MX, NI, PA, PR, SV, TT, US; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CN, GE, ID, IN, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MY, NP, PH, PK, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AU, FJ, NC, NZ, PG, SB, TL, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, LR, LS, LY, MA, MG, ML, MR, MW, MZ, NA, NE, NG, RW, SD, SL, SN, SO, SS, SZ, TD, TG, TN, TZ, UG, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): TF
